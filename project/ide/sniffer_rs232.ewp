# IAR project sniffer_rs232.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F446RC ST STM32F446RC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F446xx
  ICCARM.CCIncludePath2: ../drivers; ../drivers/cmsis/Include; ../drivers/stm32f4xx_hal_driver/Inc; ../common; ../bsp/inc; ../application/inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: sniffer_rs232.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: C:\WORK\Repos\sniffer_rs232-fw\project\ide\sniffer_rs232.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group application
    ../application/src/: cli.c config.c main.c menu.c sniffer_rs232.c stm32f4xx_it.c
  group bsp
    ../bsp/src/: bsp_crc.c bsp_gpio.c bsp_lcd1602.c bsp_led_rgb.c bsp_rcc.c bsp_uart.c
  group drivers/cmsis
    ../drivers/cmsis/Source/Templates/iar/: startup_stm32f446xx.s
    ../drivers/cmsis/Source/Templates/: system_stm32f4xx.c
  group drivers/stm32f4xx_hal_driver
    ../drivers/stm32f4xx_hal_driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
